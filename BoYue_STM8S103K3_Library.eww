<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BoYue_STM8S103K3_Library.ewp</path>
  </project>
  <batchBuild/>
</workspace>


