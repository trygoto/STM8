# IAR project Backup (3) of BoYue_STM8S103K3_Library.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; STM8S_StdPeriph_Driver\inc; STM8S_StdPeriph_Driver\src; APP; USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LH-LVDC-AXX.hex
  ILINK.IlinkOutputFile: BoYue_STM8S103K3_Library.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group APP
    APP/: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
  group STM8S_StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim2.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
  group USER
    USER/: CRC_8.c key_scan.c led.c RS232command.c seg.c task.c tim2.c UART2.c
